# Keil uVision project AAx.uvprojx, settings and files
target APP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L431CCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Output\APP.bin .\Objects\APP.axf
  AfterMake: "$P\BATS\move_hex.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000,USE_FULL_LL_DRIVER, STM32L431xx, APP
  c include: .\STM32L4 Low Layer drivers\inc;.\Source\Core\inc;.\Source\Protocols\inc;.\Source\Ext_Dev\inc;.\Source\Ext_Dev\inc\LSM6DS3;.\Source\Ext_Dev\inc\LSM303DLHC;.\Source\Ext_Dev\inc\MPU-9250;.\Source\Line\inc;.\Source\Main\inc;.\Source\MCU_Drivers\inc;.\Source\MCU_Drivers\inc;.\Source\MotionTL\inc;.\Source\RTOS\inc;.\Source\Tasks\inc;..\Lib\Objects
  asm misc: --cpreproc
  asm include: .\Source\Main\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\Objects\APP.sct
  link misc: --predefine="-DAPP" --scatter=.\Objects\APP.sct
--diag_suppress=L6989W --info=summarystack --info=totals --map
  group Ext_Dev
    ./Source/Ext_Dev/src/: Relay.cpp RS-485_phy.cpp Button.cpp Led.cpp AD8402.cpp
  group Main
    ./Source/Main/src/: main.cpp hard_config.cpp model.cpp Lib.lib
  group MCU_Drivers
    ./Source/MCU_Drivers/src/: Flash_driver.cpp I2C_driver.cpp Interface.cpp old_flash_lib.cpp SPI_dirver.cpp usart_driver_.cpp
  group RTOS
    ./Source/RTOS/src/: heap_2.c list.c port.c queue.c tasks.c timers.c
  group Protocols
    ./Source/Protocols/src/: ext_master.cpp
  group Tasks
    ./Source/Tasks/src/: settings.cpp lev_gauge_to_pc.cpp
  group Core
    ./Source/Core/src/: startup_stm32l431xx.s system_stm32l4xx.c
target DEBUG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L431CCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: as above
  output: AA00_DEBUG +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Output\AA00_DEBUG.bin .\Objects\AA00_DEBUG.axf
  AfterMake: "$P\BATS\move_hex.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000,USE_FULL_LL_DRIVER, STM32L431xx, DEBUG
  c include: .\STM32L4 Low Layer drivers\inc;.\Source\Core\inc;.\Source\Protocols\inc;.\Source\Ext_Dev\inc;.\Source\Ext_Dev\inc\LSM6DS3;.\Source\Ext_Dev\inc\LSM303DLHC;.\Source\Ext_Dev\inc\MPU-9250;.\Source\Line\inc;.\Source\Main\inc;.\Source\MCU_Drivers\inc;.\Source\MCU_Drivers\inc;.\Source\MotionTL\inc;.\Source\RTOS\inc;.\Source\Tasks\inc;.\Source\Ext_Dev\inc\AT45;.\Objects
  asm misc: --cpreproc --cpreproc_opts=-D__PROG_VERSION=0xAA000000
  asm include: .\Source\Main\inc;..\..\DKS_Multiproject;.\Objects;..\..\Prog
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\Objects\APP.sct
  link misc: --predefine="-DDEBUG" --scatter=.\Objects\APP.sct
--diag_suppress=L6989W --info=summarystack --info=totals --map
